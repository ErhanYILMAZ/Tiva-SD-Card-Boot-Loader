# Keil uVision project BootTest.uvproj, settings and files
target BootLoader (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: BootTest
  BeforeMake: armcc --device DLM -I . -E -o .\bl_config.inc .\Source\bl_config.c
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1 _USE_WRITE
  c misc: --c99
  c include: .;C:\ti\TivaWare_C_Series-2.1.0.12573
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\bl_link.sct
  link misc: --entry Reset_Handler
  group Source
    ./Source/: bl_main.c bl_check.c
    ./: bl_startup_rvmdk.S
  group Petit
    ./Petit/: diskio.h integer.h mmcbbp.c pff.c pff.h pffconf.h
