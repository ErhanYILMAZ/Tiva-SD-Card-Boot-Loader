# Keil uVision project LEDBlink.uvproj, settings and files
target LEDBlink (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: LEDBlink
  AfterMake: fromelf --bin --output .\Bin\LEDBlink.bin .\Bin\LEDBlink.axf
  c flags: Optim=1
  c include: .;C:\ti\TivaWare_C_Series-2.1.0.12573
  library: MicroLIB
  memory RVCT4: ROM 0x2800 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: main.c startup_rvmdk.S
    C:/ti/TivaWare_C_Series-2.1.0.12573/driverlib/rvmdk/: driverlib.lib
